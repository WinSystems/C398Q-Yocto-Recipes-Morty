# Copyright (C) 2016 WinSystems, Inc.
include u-boot-c398.inc

PV = "v2016.03+git${SRCPV}"

SRCREV = "0ec2a019117bb2d59b9672a145b4684313d92782"
SRCBRANCH = "imx_v2016.03_4.1.15_2.0.0_ga"
